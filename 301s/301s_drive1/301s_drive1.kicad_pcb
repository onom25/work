# Repository onom25/work

## KiCad design 301s/301s_drive1/301s_drive1.kicad_pcb

File 301s/readme.txt:

301s_drive1		ピエゾドライバー、ディスクリート版
301s_drive2		ピエゾドライバー、廉価版
301s_FT202H		FT232Hアクセスモック
FT232H_powershell	FT232H高速転送評価ツール
FT232H_quartus		301s_FT232H用のQuartus
wave_301s		cygwin 波形情報の読込、書込ツール
mmp5500_301s		DMX100の専用ファーム server\Elec\mmp301s\prototype\mmp5500_301s で管理する

Parts:
C1, C2, C10: 106/50V; CP_Radial_D5.0mm_P2.00mm
C3, C7, C8, C9, C12, C14, C15, C16, C18, C20: 104; _2012
C6: C_US; CP_Radial_D12.6mm_P5.0mm
C17, C19: 15p; _2012
CN1: B6B-PH; B06B-PH
CN2: B12B-PH
CN3: cb_02mail; B02B-PH
F1: FUSE-2A; FUSE0154_
F2: FUSE-0.5A; FUSE0154_
L1: BLM21BD272SN; _2012
Q1: TTC3710B; TO-220L
Q2: TTA1452B; TO-220L
Q13: BFJ310
Q14: C2712; 2SC2712
R1, R2: 0R2 1W; R_12
R3: 101 1/4W; R_7.62
R11, R15, R17, R18: 103; R_1608
R12, R20: 203; R_1608
R13: 333; R_1608
R14: 331; R_1608
R16, R23: 102; R_1608
R19, R27: 152; R_1608
R21: 1003; R_1608
R22, R25, R28: 1002; R_1608
R24: 202; R_1608
R26: 362; R_1608
R29, R30: 49R9F; R_1608
R31: 2001; _2012
R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42: 273; R_1608
RV2: 202VR; GF063
TP1, TP3, TP4, TP5, TP6, TP7, TP8: CB; VIA1.4_inch
U1, U4: LM1010; DIP-8_W7.62
U2, U5: OPA552UA; LM358D_SOIC
U8: LM358DR; LM358D_SOIC
U9: DAC900U; DAC900U_SOIC28

Connections:
+3V3: C12.1, C20.2, CN1.4, L1.2, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, U9.27 (+VD)
+5V: C8.1, CN1.3, R25.2, R26.1, U8.8 (V+)
/3R3A: C14.2, C18.2, L1.1, U9.24 (+VA)
/GND: CN1.5, CN1.6
/P42V: CN1.1, CN1.2, F1.1, F2.1
/P42V1: C1.1, C2.1, C3.1, C7.1, C9.2, C10.1, F2.2, R19.1, U1.1 (V+), U2.7 (V+), U4.1 (V+), U5.7 (V+); also elsewhere on the board
/P42V2: C6.1, F1.2, Q1.C
/WAVE: Q14.E, R23.1, R24.2, R28.1
GND1: C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C9.1, C10.2, C12.2, C14.1, C15.2, C16.1, C17.2, C19.2, C20.1, CN2.12, CN3.2, Q2.C, R12.2, R17.2, R20.2, R22.2, R27.2, R29.1, R30.1, R31.2, TP4.1, U1.6 (V-), U2.1 (V-), U2.4 (V-), U2.5 (V-), U4.6 (V-), U5.1 (V-), U5.4 (V-), U5.5 (V-), U8.4 (V-), U8.5 (+), U9.16 (~INT/EXT), U9.20 (AGND), U9.26 (DGND); also elsewhere on the board
unnamed: CN2.1, R42.2, U9.1 (Bit1)
unnamed: CN2.2, R41.2, U9.2 (Bit2)
unnamed: CN2.3, R40.2, U9.3 (Bit3)
unnamed: CN2.4, R39.2, U9.4 (Bit4)
unnamed: CN2.5, R38.2, U9.5 (Bit5)
unnamed: CN2.6, R37.2, U9.6 (Bit6)
unnamed: CN2.7, R36.2, U9.7 (Bit7)
unnamed: CN2.8, R35.2, U9.8 (Bit8)
unnamed: CN2.9, R34.2, U9.9 (Bit9)
unnamed: CN2.10, R33.2, U9.10 (Bit10)
unnamed: CN2.11, R32.2, U9.28 (CLK)
unnamed: CN3.1, R1.1, R2.2, R3.1, TP3.1
unnamed: Q1.B, Q2.B, R3.2, U1.3
unnamed: Q1.E, R1.2
unnamed: Q2.E, R2.1
unnamed: Q13.G, U8.1
unnamed: Q13.S, Q14.B, R24.1
unnamed: R13.1, R14.2
unnamed: R16.1, U4.3
unnamed: R18.1, R19.2
unnamed: R26.2, RV2.3
unnamed: R11.1, U1.8 (INPUT)
unnamed: R16.2, U2.3 (+IN)
unnamed: R14.1, R15.2, U2.2 (-IN)
unnamed 33: R12.1, TP5.1, U2.8 (Flag); also elsewhere on the board
unnamed: R11.2, R13.2, TP1.1, U2.6 (OUT)
unnamed: R17.1, R18.2, U4.8 (INPUT)
unnamed: R23.2, U5.3 (+IN)
unnamed: R21.1, R22.1, U5.2 (-IN)
unnamed: R20.1, U5.8 (Flag)
unnamed: R15.1, R21.2, TP6.1, U5.6 (OUT)
unnamed: R27.1, RV2.1, RV2.2, TP8.1, U8.3 (+)
unnamed: Q13.D, Q14.C, R25.1, U8.2 (-)
unnamed: U8.6 (-), U8.7
unnamed: C18.1, U9.19 (BW)
unnamed: C15.1, U9.23 (BYP)
unnamed: R31.1, U9.18 (FSA)
unnamed: C19.1, R28.2, R29.2, TP7.1, U9.22 (IOUT)
unnamed: C16.2, U9.17 (REFin)
unnamed: C17.1, R30.2, U9.21 (~IOUT)

Notes on the sheet:
min 1.26V max 2.26V
Step1 出力段評価 5Pコネクタ 1,2-42V 3-Sig 4,5-GND TP1に104プルダウン
min 1.05V max 1.47V
19.5V
Ix 1.2mA
Vo=(1+100/10) x Vi =11 x Vi x11 min 13.86V max 24.86V Center 19.36V 11.0Vp-p
Vo=(33.6/10) x Vi =3.33 x Vi x3.32 min 1.6512V max 38.28V Center 6.688V 36.63Vp-p
min 0.06V max 1.06V

Board: 2 copper layers, 79 parts (0 on the bottom side), 49 nets, no tracks yet.

Other parts of the board:
C4: 106/50V; CP_Radial_D5.0mm_P2.00mm
C5: 104; _2012
R10: 273; R_1608
TP2: CB; VIA1.4_inch

Their connections:
/P42V1: C4.1, C5.1; also elsewhere on the board
GND1: C4.2, C5.2, R10.2; also elsewhere on the board
unnamed 33: R10.1, TP2.1; also elsewhere on the board

## KiCad design 301s/301s_drive2/301s_drive2.kicad_pcb

Parts:
C1: 687 50V; CP_Radial_D12.6mm_P5.0mm
C2: 104; _2012
CN1: B6B-PH; B06B-PH
CN2: B12B-PH
CN3: cb_02mail; B02B-PH
F1: FUSE-2A; FUSE0154_
F2: FUSE-0.5A; FUSE0154_
Q1: TTC3710B; TO-220L
Q2: TTA1452B; TO-220L
R1, R2: 101; R_1608
R3, R4: 100; R_7.62
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 273; R_1608
TP1, TP2: CB; VIA1.4_inch
U1: E09A88GA; E09A88GA_SOIC24

Connections:
+3V3: C2.1, CN1.4, R5.2, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U1.18 (V3P3)
/GND: CN1.5, CN1.6
/P42V: CN1.1, CN1.2, F1.1, F2.1
/P42V1: F2.2, U1.16 (V42)
/P42V2: C1.1, F1.2, Q1.C
GND1: C1.2, C2.2, CN2.12, CN3.2, Q2.C, TP2.1, U1.6 (~RST), U1.8 (NC_8), U1.9 (GND_9), U1.10 (GND_10), U1.11 (GND(BP)), U1.15 (NC_15), U1.17 (NC_17)
unnamed: CN2.1, R6.2, U1.4 (D0)
unnamed: CN2.2, R7.2, U1.3 (D1)
unnamed: CN2.3, R8.2, U1.2 (D2)
unnamed: CN2.4, R9.2, U1.1 (D3)
unnamed: CN2.5, R10.2, U1.24 (D4)
unnamed: CN2.6, R11.2, U1.23 (D5)
unnamed: CN2.7, R12.2, U1.22 (D6)
unnamed: CN2.8, R13.2, U1.21 (D7)
unnamed: CN2.9, R14.2, U1.20 (D8)
unnamed: CN2.10, R15.2, U1.19 (D9)
unnamed: CN2.11, R16.2, U1.5 (CLK)
unnamed: CN3.1, Q1.E, Q2.E, R1.1, R2.2, TP1.1, U1.13 (FB)
unnamed: Q1.B, R1.2, R3.1
unnamed: Q2.B, R2.1, R4.1
unnamed: R3.2, U1.14 (BNPN)
unnamed: R4.2, U1.12 (BPNP)
unnamed: R5.1, U1.7 (~STB)

Board: 2 copper layers, 28 parts (0 on the bottom side), 23 nets, no tracks yet.

## KiCad design 301s/301s_FT202H/mmp510-cnt40.kicad_pcb

Board: 2 copper layers, 169.0 x 46.0 mm, 106 parts (0 on the bottom side), 97 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C101, C102, C103, C104: 226; CP_Elec_6.3x6.1
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C120: 104; C_0402
CN1, CN9: 15FMN-BTRK-A
CN2, CN13: B5B-PH; B05B-PH
CN4, CN14: B8B-PH; B08B-PH
CN5, CN15: B6B-PH; B06B-PH
CN6, CN7, CN16: B3B-PH; B03B-PH
CN11, CN12: 31FMN-BTRK-A
D1, D2: LED; LED_0603_HandSoldering
IC1: SN65LVDS93; TSSOP56-P-300-0.5
IC2, IC3, IC4: DS90LV012; SSOP5-P-0.95
IC5: SG-210STF 24.0000ML; SG210
IC6, IC16: LM1086CSX-3.3; LM1086CX
IC11: SN65LVDS94; TSSOP56-P-300-0.5
IC12, IC13, IC14: DS90LV011; SSOP5-P-0.95
IC15: LM358; TL7733_CD
L1, L2, L11, L12: BLM21BD272SN; C_2012
R1, R2, R28, R29, R119, R120, R121, R122: 473; R_1608
R3, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R118: 220; R_1608
R4, R124: 102; R_1608
R30, R31, R32, R115, R116, R117: 101; R_1608
R123: 4.7k/1%; R_1608
TP1, TP2: TP-TH; TP_small
TP101, TP102, TP103: TP; TP_small

Connections:
+5V: C101.1, C105.1, C114.1, CN16.1, IC15.8 (V+), IC16.VI (1)
/LVDSVCC1: C1.1, C8.1, IC1.44 (LVDSVCC), L1.2
/PLLVCC1: C2.1, C10.1, IC1.34 (PLLVCC), L2.2
/Printer Head Interface/CH: CN11.28, R111.2
/Printer Head Interface/COM: CN11.9, CN11.11, CN11.13, CN11.15, CN11.18, CN11.20, CN11.22, CN11.24, CN12.9, CN12.11, CN12.13, CN12.15, CN12.18, CN12.20, CN12.22, CN12.24, CN13.3, CN13.4, TP1.1
/Printer Head Interface/LAT: CN11.6, R109.2
/Printer Head Interface/LVDSVCC2: C103.1, C108.1, IC11.13 (LVDSVCC), L11.2
/Printer Head Interface/NCHG: CN11.26, R110.2
/Printer Head Interface/PAin: CN9.2, IC13.5 (A1), R120.1
/Printer Head Interface/PBin: CN9.4, IC14.5 (A1), R122.1
/Printer Head Interface/PLLVCC2: C104.1, C110.1, IC11.23 (PLLVCC), L12.2
/Printer Head Interface/SCK: CN12.28, R112.2
/Printer Head Interface/SI1: CN12.3, R101.2
/Printer Head Interface/SI2: CN12.5, R102.2
/Printer Head Interface/SI3: CN12.26, R103.2
/Printer Head Interface/SI4: CN12.30, R104.2
/Printer Head Interface/SI5: CN11.4, R105.2
/Printer Head Interface/SI6: CN11.2, R106.2
/Printer Head Interface/SI7: CN11.27, R107.2
/Printer Head Interface/SI8: CN11.29, R108.2
/Printer Head Interface/THin: CN12.6, IC15.3 (+), R123.1
/Printer Head Interface/VHV: CN12.1, CN13.1
/Printer Head Interface/XHOT: CN11.30, IC12.5 (A1), R119.1
/THout: CN1.14, CN4.7
/TXCLK: CN2.1, IC1.31 (CLKIN), R3.2
GND1: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, CN1.15, CN2.2, CN2.5, CN6.2, CN6.3, CN7.2, CN7.3, D1.1 (K), IC1.5 (GND), IC1.13 (GND), IC1.21 (GND), IC1.29 (GND), IC1.33 (PLLGND), IC1.35 (PLLGND), IC1.36 (LVDSGND), IC1.43 (LVDSGND), IC1.49 (LVDSGND), IC1.53 (GND), IC2.2 (GND), IC3.2 (GND), IC4.2 (GND), IC5.2 (GND), IC6.GND (2)
GND2: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, CN9.5, CN11.3, CN11.5, CN11.7, CN11.8, CN11.10, CN11.12, CN11.14, CN11.17, CN11.19, CN11.21, CN11.23, CN11.25, CN12.2, CN12.4, CN12.7, CN12.8, CN12.10, CN12.12, CN12.14, CN12.17, CN12.19, CN12.21, CN12.23, CN12.25, CN12.27, CN12.29, CN12.31, CN13.2, CN13.5, CN16.2, CN16.3, D2.1 (K), IC11.4 (GND), IC11.8 (LVDSGND), IC11.14 (LVDSGND), IC11.21 (LVDSGND), IC11.22 (PLLGND), IC11.24 (PLLGND), IC11.28 (GND), IC11.36 (GND), IC11.44 (GND), IC11.52 (GND), IC12.2 (GND), IC13.2 (GND), IC14.2 (GND), IC15.4 (V-), IC15.5 (+), IC16.GND (2), TP2.1
unnamed: CN1.1, IC1.14 (D14)
unnamed: CN1.2, IC1.51 (D0)
unnamed: CN1.3, IC1.52 (D1)
unnamed: CN1.4, IC1.54 (D2)
unnamed: CN1.5, IC1.55 (D3)
unnamed: CN1.6, IC1.56 (D4)
unnamed: CN1.7, IC1.3 (D6)
unnamed: CN1.8, IC1.4 (D7)
unnamed: CN1.9, IC1.6 (D8)
unnamed: CN1.10, IC1.7 (D9)
unnamed: CN1.11, IC1.11 (D12)
unnamed: CN1.12, IC1.12 (D13)
unnamed: CN1.13, IC2.5 (TTLOUT)
unnamed: CN2.3, IC3.5 (TTLOUT)
unnamed: CN2.4, IC4.5 (TTLOUT)
unnamed: CN4.1, IC1.47 (Y0P)
unnamed: CN4.2, IC1.48 (Y0M)
unnamed: CN4.3, IC1.45 (Y1P)
unnamed: CN4.4, IC1.46 (Y1M)
unnamed: CN4.5, IC1.39 (CLKOUTP)
unnamed: CN4.6, IC1.40 (CLKOUTM)
unnamed: CN5.1, IC2.3 (IN+), R30.2
unnamed: CN5.2, IC2.4 (IN-), R30.1
unnamed: CN5.3, IC3.3 (IN+), R31.2
unnamed: CN5.4, IC3.4 (IN-), R31.1
unnamed: CN5.5, IC4.3 (IN+), R32.2
unnamed: CN5.6, IC4.4 (IN-), R32.1
unnamed: C3.1, C5.1, CN6.1, CN7.1, IC6.VI (1)
unnamed: CN14.1, IC11.10 (A0P), R115.2
unnamed: CN14.2, IC11.9 (A0M), R115.1
unnamed: CN14.3, IC11.12 (A1P), R116.2
unnamed: CN14.4, IC11.11 (A1M), R116.1
unnamed: CN14.5, IC11.18 (CLKINP), R117.2
unnamed: CN14.6, IC11.17 (CLKINM), R117.1
unnamed: CN14.7, IC15.1, IC15.2 (-)
unnamed: CN15.1, IC12.4 (Y)
unnamed: CN15.2, IC12.3 (/Y)
unnamed: CN15.3, IC13.4 (Y)
unnamed: CN15.4, IC13.3 (/Y)
unnamed: CN15.5, IC14.4 (Y)
unnamed: CN15.6, IC14.3 (/Y)
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R124.2
unnamed: IC1.15 (D15), R28.2
unnamed: IC1.19 (D18), R29.2
unnamed: IC1.17 (CLKSEL), R1.2
unnamed: IC1.32 (/SHTDN), R2.2
unnamed: IC5.3 (Output), R3.1
unnamed: IC11.27 (D0), R101.1
unnamed: IC11.29 (D1), R102.1
unnamed: IC11.30 (D2), R103.1
unnamed: IC11.32 (D3), R104.1
unnamed: IC11.33 (D4), R105.1
unnamed: IC11.35 (D6), R106.1
unnamed: IC11.37 (D7), R107.1
unnamed: IC11.38 (D8), R108.1
unnamed: IC11.39 (D9), R109.1
unnamed: IC11.43 (D12), R110.1
unnamed: IC11.45 (D13), R111.1
unnamed: IC11.46 (D14), R112.1
unnamed: IC11.47 (D15), R113.1
unnamed: IC11.51 (D18), R114.1
unnamed: IC11.26 (CLKOUT), R118.1
unnamed: IC11.25 (/SHTDN), R121.2
unnamed: IC15.6 (-), IC15.7
unnamed: R113.2, TP101.1
unnamed: R114.2, TP102.1
unnamed: R118.2, TP103.1
VCC: C102.1, C106.1, C107.1, C109.1, C111.1, C112.1, C113.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, CN9.3, CN11.1, CN11.31, IC11.31 (VCC), IC11.40 (VCC), IC11.48 (VCC), IC11.56 (VCC), IC12.1 (VCC), IC13.1 (VCC), IC14.1 (VCC), IC16.VO (3), L11.1, L12.1, R119.2, R120.2, R121.1, R122.2, R123.2, R124.1
VDD: C4.1, C6.1, C7.1, C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, IC1.1 (VCC), IC1.9 (VCC), IC1.26 (VCC), IC2.1 (VCC), IC3.1 (VCC), IC4.1 (VCC), IC5.4 (VCC), IC6.VO (3), L1.1, L2.1, R1.1, R2.1, R4.1, R28.1, R29.1

## Code that names these connections

File 301s/wave_301s/wave_301s.c (part):

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		//-- 転送データの試験用
		for (i=wave_info.WAVE001/2; i<wave_info.WAVE001/2+40; i++) {
			wave_info.wave[i].WAVE_MEM.BIT.DAC = i;
			wave_info.wave[i].WAVE_MEM.BIT.LAT = 0;
			wave_info.wave[i].WAVE_MEM.BIT.CH = 0;
			wave_info.wave[i].WAVE_MEM.BIT.NCHG = 1;
			wave_info.wave[i].WAVE_MEM.BIT.ENB = 1;
		}
		wave_info.wave[i].WAVE_MEM.BIT.DAC = i;
		wave_info.wave[i].WAVE_MEM.BIT.LAT = 0;
		wave_info.wave[i].WAVE_MEM.BIT.CH = 0;
		wave_info.wave[i].WAVE_MEM.BIT.NCHG = 0;
		wave_info.wave[i].WAVE_MEM.BIT.ENB = 0;
		sprintf (tbf+ 0, "STOP\x0");
		disp_wave_info (tbf);		//-- 値の確認
#endif
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
## Commit log (part)

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2026-05-12 first backup 20260512
2026-05-13 updatt
2026-05-13 add kicad9
2026-05-13 Add kicad project
2026-05-13 KiCAD add retry
2026-05-13 KiCAD add dmx100 circuit pdf
2026-05-14 Add /mechanical CAD directory
2026-05-15 belt sample
2026-05-15 add Mechanical Puly
2026-05-15 add puly
2026-05-18 update sch
2026-05-18 add device datasheet
2026-05-21 remove old PDF
2026-05-25 20260525 update
2026-06-05 update 20260605
2026-06-08 update 20260608
2026-06-08 updata 20260608-2
2026-06-16 add drive1
